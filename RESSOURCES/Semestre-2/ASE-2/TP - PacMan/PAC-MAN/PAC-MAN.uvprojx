# Keil uVision project PAC-MAN.uvprojx, settings and files
target Simulation (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boule
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NEW_LCD
  c include: .\h
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Sources
    ./src/: ball.c button.c formes.c game.c GLCD_Fonts.c GLCD_MCBSTM32E.c main.c timers.c menu.c GPIO.c GLCD.c
  group Headers
    ./h/: ball.h Board_GLCD.h button.h ext_globales.h fantome.h formes.h game.h GLCD_Config.h globales.h menu.h registres.h timers.h types.h GPIO.h ExtGlobales.h GLCD.h
target DebugInSitu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: boule
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\h
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
